SRC_URI = "git://git.efficios.com/babeltrace.git;branch=stable-1.5;protocol=https \
	   file://run-ptest \
	  "
