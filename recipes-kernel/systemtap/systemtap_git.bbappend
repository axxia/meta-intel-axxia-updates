SRC_URI = "git://sourceware.org/git/systemtap.git;branch=master;protocol=https \
           file://0001-Do-not-let-configure-write-a-python-location-into-th.patch \
           file://0001-Install-python-modules-to-correct-library-dir.patch \
           file://0001-staprun-stapbpf-don-t-support-installing-a-non-root.patch \
           file://0001-transport-protect-include-and-callsite-with-same-con.patch \
           file://ef5a8b9eda402e4e96c4e3ce01e7ff95d3e10470.patch \
           file://0001-improve-reproducibility-for-c-compiling.patch \
           "
