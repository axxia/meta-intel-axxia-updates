SRC_URI = "git://git.kernel.org/pub/scm/utils/dtc/dtc.git;branch=master;protocol=https \
           file://make_install.patch \
           file://0001-dtc-Fix-Makefile-to-add-CFLAGS-not-override.patch \
           file://0001-fdtdump-Fix-gcc11-warning.patch \
          "
