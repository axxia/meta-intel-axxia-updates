SRC_URI = "https://download.automotivelinux.org/AGL/mirror/ipmiutil-${PV}.tar.gz \
           file://fix_systemd_path.patch \
           file://0001-Prevent-access-times-from-changing-resulting-gzip-md.patch \
          "
