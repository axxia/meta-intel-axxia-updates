SRC_URI = "git://git.kernel.org/pub/scm/linux/kernel/git/gong.chen/aer-inject.git;protocol=https \
           file://include-libgen-version-of-basename-function.patch \
          "
