SRC_URI = "git://git.kernel.org/pub/scm/utils/kernel/kmod/kmod.git;branch=master;protocol=https \
           file://depmod-search.conf \
           file://avoid_parallel_tests.patch \
           "
