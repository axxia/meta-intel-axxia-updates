SRC_URI = "git://git.samba.org/cifs-utils.git;branch=master;protocol=https"
