SRC_URI = "https://libbsd.freedesktop.org/releases/libmd-${PV}.tar.xz"
