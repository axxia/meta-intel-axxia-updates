SRC_URI = "https://sourceforge.net/projects/boost/files/boost/${PV}/${BOOST_P}.tar.bz2 \
	file://bjam-native-build-bjam.debug.patch \
	file://build.sh-use-DNDEBUG-also-in-debug-builds.patch \
	"
