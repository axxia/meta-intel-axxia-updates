SRC_URI = "https://download.automotivelinux.org/AGL/mirror/${BP}.tar.gz \
           file://sepbuildfix.patch \
          "
