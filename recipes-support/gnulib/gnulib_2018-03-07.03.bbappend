SRC_URI = "git://git.savannah.gnu.org/git/gnulib.git;branch=master;protocol=https"
