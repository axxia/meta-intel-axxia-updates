SRC_URI = "git://git.kernel.org/pub/scm/utils/cpu/mce/mce-test.git;protocol=https;branch=master \
           file://makefile-remove-ldflags.patch \
           file://0001-gcov_merge.py-scov_merge.py-switch-to-python3.patch \
          "
