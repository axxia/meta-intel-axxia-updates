SRC_URI = "git://git.yoctoproject.org/ptest-runner2;branch=master;protocol=https"
