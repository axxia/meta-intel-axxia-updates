SRC_URI = "https://ftp.osuosl.org/pub/libpng/src/${BPN}/${BPN}-${PV}.tar.xz \
           file://ldflags-tests.patch \
           file://CVE-2018-25032.patch \
           file://run-ptest \
           "
