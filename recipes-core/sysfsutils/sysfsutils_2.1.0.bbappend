SRC_URI = "https://mirror.math.princeton.edu/pub/tinycorelinux/12.x/aarch64/tcz/src/${BPN}/${BPN}-${PV}.tar.gz \
           file://sysfsutils-2.0.0-class-dup.patch \
           file://obsolete_automake_macros.patch \
           file://separatebuild.patch"
