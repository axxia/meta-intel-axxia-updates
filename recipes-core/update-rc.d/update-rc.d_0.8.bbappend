SRC_URI = "git://git.yoctoproject.org/update-rc.d;branch=master;protocol=https"
