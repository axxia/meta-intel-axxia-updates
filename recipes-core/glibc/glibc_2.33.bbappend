GLIBC_GIT_URI = "git://sourceware.org/git/glibc.git;protocol=https"
