SRC_URI = "https://artfiles.org/ubuntu.com/pool/main/n/${BPN}/${BPN}_${PV}.tar.xz"
