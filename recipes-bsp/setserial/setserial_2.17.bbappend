SRC_URI = "http://slackware.uk/slackware/slackware64-13.37/source/a/util-linux/${BPN}-${PV}.tar.gz \
           file://add_stdlib.patch \
           file://ldflags.patch \
          "
