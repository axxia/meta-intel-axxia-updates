SRC_URI = "https://download.automotivelinux.org/AGL/mirror/${BPN}-${PV}.tar.gz \
           file://ldflags.patch \
           file://musl.patch \
           file://init"
