SRC_URI = "git://github.com/rhinstaller/efibootmgr.git;protocol=https;branch=main \
           file://0001-remove-extra-decl.patch \
           file://97668ae0bce776a36ea2001dea63d376be8274ac.patch \
          "
