DEBIAN_MIRROR = "https://archive.debian.org/debian/pool"
