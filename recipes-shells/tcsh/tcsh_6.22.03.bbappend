SRC_URI = " \
    https://mirror.dogado.de/BLFS/conglomeration/${BPN}/${BP}.tar.gz \
    file://0001-Enable-system-malloc-on-all-linux.patch \
    file://0002-Add-debian-csh-scripts.patch \
"
