SRC_URI = "git://git.yoctoproject.org/pseudo;branch=oe-core;protocol=https \
           file://0001-configure-Prune-PIE-flags.patch \
           file://fallback-passwd \
           file://fallback-group \
           "
