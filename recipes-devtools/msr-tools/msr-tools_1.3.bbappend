SRC_URI = "https://download.automotivelinux.org/AGL/mirror/msr-tools-${PV}.zip"
