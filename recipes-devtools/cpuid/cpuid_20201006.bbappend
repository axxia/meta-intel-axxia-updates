SRC_URI = "https://mirror.iscas.ac.cn/yocto/mirror/sources/${BP}.src.tar.gz"
