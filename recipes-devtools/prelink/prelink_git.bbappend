SRC_URI = "git://git.yoctoproject.org/prelink-cross.git;branch=cross_prelink_staging;protocol=https \
           file://0001-Add-MIPS-gnu-hash-support.patch \
           file://prelink.conf \
           file://prelink.cron.daily \
           file://prelink.default \
           file://macros.prelink \
           "
