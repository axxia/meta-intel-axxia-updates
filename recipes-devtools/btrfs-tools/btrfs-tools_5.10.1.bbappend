SRC_URI = "git://git.kernel.org/pub/scm/linux/kernel/git/kdave/btrfs-progs.git;branch=master;protocol=https \
           file://0001-Add-a-possibility-to-specify-where-python-modules-ar.patch \
           "
