SRC_URI = "https://mirror.metanet.ch/BLFS/conglomeration/docbook-xsl/docbook-xsl-${PV}.tar.bz2 \
           file://docbook-xsl-stylesheets-no-bashism-in-docbook-xsl-up.patch \
"
