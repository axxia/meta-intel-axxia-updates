SRC_URI = "git://git.kernel.org/pub/scm/fs/ext2/e2fsprogs.git;branch=master;protocol=https \
           file://0001-e2fsck-fix-last-mount-write-time-when-e2fsck-is-forc.patch \
           file://remove.ldconfig.call.patch \
           file://run-ptest \
           file://ptest.patch \
           file://mkdir_p.patch \
           "
