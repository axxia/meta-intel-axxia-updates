SRC_URI = "https://mirror.iscas.ac.cn/yocto/mirror/sources/${BPN}-${PV}.tar.gz \
           file://0001-gptcurses-correctly-include-curses.h.patch \
           "
