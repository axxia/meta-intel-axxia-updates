SRC_URI = "https://mirrors.omnios.org/${BPN}/${BPN}-${PV}.tar.bz2 \
	file://0001-Don-t-set-uid-gid-during-install.patch \
	"
