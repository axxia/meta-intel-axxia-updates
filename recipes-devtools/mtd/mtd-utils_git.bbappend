SRC_URI = "git://github.com/sigma-star/mtd-utils.git;branch=master;protocol=https \
           file://add-exclusion-to-mkfs-jffs2-git-2.patch \
           "
