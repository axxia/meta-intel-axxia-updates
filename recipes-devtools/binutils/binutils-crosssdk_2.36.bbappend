BINUTILS_GIT_URI = "git://sourceware.org/git/binutils-gdb.git;branch=${BRANCH};protocol=https"
