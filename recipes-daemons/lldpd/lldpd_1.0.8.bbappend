SRC_URI = " \
    https://petalinux.xilinx.com/sswreleases/rel-v2022/downloads/${BPN}-${PV}.tar.gz \
    file://lldpd.init.d \
    file://lldpd.default \
    "
