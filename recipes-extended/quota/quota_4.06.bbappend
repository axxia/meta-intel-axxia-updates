SRC_URI = "https://download.iopsys.eu/iopsys/mirror/${BPN}-${PV}.tar.gz \
           file://fcntl.patch \
           file://0001-quota-Use-realloc-3-instead-of-reallocarray-3.patch \
          "
