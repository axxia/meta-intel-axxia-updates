SRC_URI = "https://mirror-hk.koddos.net/blfs/conglomeration/${BPN}/${BPN}-${PV}.tar.gz \
           file://wiper.sh-fix-stat-path.patch \
"
