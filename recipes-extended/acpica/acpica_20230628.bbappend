SRC_URI = "http://sources.buildroot.net/acpica/acpica-unix-${PV}.tar.gz"
