SRC_URI = "https://mirror.iscas.ac.cn/yocto/mirror/sources/acpica-unix-${PV}.tar.gz"
