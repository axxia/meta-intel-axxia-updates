SRC_URI = "https://invisible-mirror.net/archives/${BPN}/${BP}.tgz"
