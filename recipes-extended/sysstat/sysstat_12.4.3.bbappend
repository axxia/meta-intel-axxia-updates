SRC_URI = "https://petalinux.xilinx.com/sswreleases/rel-v2022/downloads/${BP}.tar.xz \
           file://99_sysstat \
           file://sysstat.service \
           file://0001-configure.in-remove-check-for-chkconfig.patch \
          "
