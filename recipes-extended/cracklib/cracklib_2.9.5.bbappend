SRC_URI = "https://mirror.metanet.ch/BLFS/conglomeration/${BPN}/${BPN}-${PV}.tar.gz \
           file://0001-packlib.c-support-dictionary-byte-order-dependent.patch \
           file://0001-Apply-patch-to-fix-CVE-2016-6318.patch \
           file://0002-craklib-fix-testnum-and-teststr-failed.patch"
