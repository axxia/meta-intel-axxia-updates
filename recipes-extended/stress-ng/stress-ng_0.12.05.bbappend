SRC_URI = "https://support.garz-fricke.com/mirror/${BP}.tar.xz \
           file://0001-Do-not-preserve-ownership-when-installing-example-jo.patch \
           "
