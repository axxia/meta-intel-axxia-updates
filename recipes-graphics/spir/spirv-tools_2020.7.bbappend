SRC_URI = "git://github.com/KhronosGroup/SPIRV-Tools.git;branch=main;protocol=https \
           file://0001-fix-strncpy-bound-error.patch \
          "
